File: Power Distrobution Board/current_sensors.kicad_sch (KiCad schematic)
At the start: 24 parts, among them U10 ACS71240LLCBTR-025B3, U11 ACS71240LLCBTR-025B3, U12 ACS71240LLCBTR-025B3, U16 ACS71240LLCBTR-025B3, U17 ACS71240LLCBTR-025B3, U2 ACS71240LLCBTR-025B3, U3 ACS71240LLCBTR-025B3, U4 ACS71240LLCBTR-025B3, U5 ACS71240LLCBTR-025B3, U7 ACS71240LLCBTR-025B3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

Commit message: version 1.1
Parts:
- added C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22: C_Small, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C_Small
Connections:
- net +3.3V: now also C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2
- net GND: now also C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1

Commit message: changes after cdr
Parts:
- C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22: value C_Small -> 0.1nF
Changed lines of the file:
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@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 269.24 109.2135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 186.69 71.1135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 193.04 34.2835 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 116.84 72.3835 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 203.2 146.0435 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 116.84 34.2835 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 269.24 71.1135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 119.38 146.0435 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 186.69 109.2135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 121.92 109.2135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 269.24 33.0135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "C_Small"
+		(property "Value" "0.1nF"
 			(at 269.24 144.7735 0)
 			(effects

Commit message: even newer changes
Changed lines of the file:
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@@
 	)
 	(global_label "shutdown_out"
-		(shape input)
+		(shape output)
 		(at 93.98 29.21 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "etc_out"
-		(shape input)
+		(shape output)
 		(at 168.91 29.21 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "extra1_out"
-		(shape input)
+		(shape output)
 		(at 240.03 27.94 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "bspd_viout"
-		(shape input)
+		(shape output)
 		(at 168.91 113.03 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "pd_board_out"
-		(shape input)
+		(shape output)
 		(at 240.03 138.43 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "accumulator_viout"
-		(shape input)
+		(shape output)
 		(at 93.98 149.86 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "dash_viout"
-		(shape input)
+		(shape output)
 		(at 168.91 76.2 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "extra2_out"
-		(shape input)
+		(shape output)
 		(at 240.03 64.77 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "extra1_viout"
-		(shape input)
+		(shape output)
 		(at 240.03 38.1 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "tractive_viout"
-		(shape input)
+		(shape output)
 		(at 240.03 111.76 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "tractive_out"
-		(shape input)
+		(shape output)
 		(at 240.03 101.6 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "telemetry_out"
-		(shape input)
+		(shape output)
 		(at 93.98 66.04 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "shutdown_viout"
-		(shape input)
+		(shape output)
 		(at 93.98 39.37 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "extra2_viout"
-		(shape input)
+		(shape output)
 		(at 240.03 74.93 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "brake_pressure_sensor_viout"
-		(shape input)
+		(shape output)
 		(at 168.91 149.86 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "accumulator_out"
-		(shape input)
+		(shape output)
 		(at 93.98 139.7 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "ready_to_move_out"
-		(shape input)
+		(shape output)
 		(at 93.98 102.87 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "bspd_out"
-		(shape input)
+		(shape output)
 		(at 168.91 102.87 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "brake_pressure_sensor_out"
-		(shape input)
+		(shape output)
 		(at 168.91 139.7 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "dash_out"
-		(shape input)
+		(shape output)
 		(at 168.91 66.04 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "ready_to_move_viout"
-		(shape input)
+		(shape output)
 		(at 93.98 113.03 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "etc_viout"
-		(shape input)
+		(shape output)
 		(at 168.91 39.37 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "pd_board_viout"
-		(shape input)
+		(shape output)
 		(at 240.03 148.59 0)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "telemetry_viout"
-		(shape input)
+		(shape output)
 		(at 93.98 76.2 0)
 		(fields_autoplaced yes)
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "3a"
+		(property "Netclass" "3A"
 			(at 93.4085 137.16 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "1a"
+		(property "Netclass" "1A"
 			(at 93.4085 26.67 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "3a"
+		(property "Netclass" "3A"
 			(at 239.4585 25.4 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "10a"
+		(property "Netclass" "10A"
 			(at 239.4585 62.23 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "3a"
+		(property "Netclass" "3A"
 			(at 168.3385 100.33 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "3a"
+		(property "Netclass" "3A"
 			(at 93.4085 63.5 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "10a"
+		(property "Netclass" "10A"
 			(at 239.4585 99.06 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "3a"
+		(property "Netclass" "3A"
 			(at 239.4585 135.89 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "3a"
+		(property "Netclass" "3A"
 			(at 168.3385 26.67 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "3a"
+		(property "Netclass" "3A"
 			(at 168.3385 63.5 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "1a"
+		(property "Netclass" "1A"
 			(at 93.4085 100.33 0)
 			(effects
@@
 			(justify left bottom)
 		)
-		(property "Netclass" "1a"
+		(property "Netclass" "1A"
 			(at 70.5485 26.67 0)
 			(effects

Commit message: updated cap values
Parts:
- C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22: value 0.1nF -> 0.1uF
Changed lines of the file:
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@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 269.24 109.2135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 186.69 71.1135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 193.04 34.2835 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 116.84 72.3835 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 203.2 146.0435 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 116.84 34.2835 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 269.24 71.1135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 119.38 146.0435 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 186.69 109.2135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 121.92 109.2135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 269.24 33.0135 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "0.1nF"
+		(property "Value" "0.1uF"
 			(at 269.24 144.7735 0)
 			(effects

Commit message: made changes per nathaniel
Parts:
- added R10, R11, R12, R13, R2, R3, R4, R5, R6, R7, R8, R9: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_Small_US
Connections:
- net +3.3V: now also R10.1, R11.1, R12.1, R13.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1
- net at U12.6 (FAULT): now also R5.2
- net at U4.6 (FAULT): now also R7.2
- net at U16.6 (FAULT): now also R12.2
- net at U10.6 (FAULT): now also R11.2
- net at U7.6 (FAULT): now also R3.2
- net at U17.6 (FAULT): now also R13.2
- net at U3.6 (FAULT): now also R8.2
- net at U5.6 (FAULT): now also R6.2
- net at U8.6 (FAULT): now also R9.2
- net at U11.6 (FAULT): now also R4.2
- net at U2.6 (FAULT): now also R2.2
- net at U9.6 (FAULT): now also R10.2
- no-connect marks 12 -> 0
