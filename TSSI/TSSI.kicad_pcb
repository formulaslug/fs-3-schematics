File: TSSI/TSSI.kicad_pcb (KiCad board)
At the start: 2 copper layers, 4 parts, among them U3 LM555xN, U5 LM7805_TO220

Commit message: push up to date changes
Parts:
- added C1: 20uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (146.5, 47.1)
- added C2: 10nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (146.5, 50.1)
- added CR1: STS6NF20V, footprints:PG-SOT23-3-5_INF, F.Cu at (27.8, 81.1)
- added CR2: BSS806NEH6327XTSA1, footprints:PG-SOT23-3-5_INF, F.Cu at (27.8, 86.0)
- added CR3: BSS806NEH6327XTSA1, footprints:PG-SOT23-3-5_INF, F.Cu at (27.8, 90.9)
- added D1: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (216.8, 27.6)
- added D10: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (216.8, 34.4)
- added D11: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (220.5, 34.4)
- added D12: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (224.3, 34.4)
- added D13: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (228.0, 34.4)
- added D14: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (231.7, 34.4)
- added D15: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (235.4, 34.4)
- added D16: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (239.1, 34.4)
- added D17: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (242.8, 34.4)
- added D18: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (246.6, 34.4)
- added D19: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (216.8, 41.1)
- added D2: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (220.5, 27.6)
- added D20: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (220.5, 41.1)
- added D21: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (224.3, 41.1)
- added D22: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (228.0, 41.1)
- added D23: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (232.8, 61.6)
- added D24: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (236.5, 61.6)
- added D25: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (240.2, 61.6)
- added D26: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (244.0, 61.6)
- added D27: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (247.7, 61.6)
- added D28: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (217.9, 68.4)
- added D29: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (221.7, 68.4)
- added D3: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (224.3, 27.6)
- added D30: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (225.4, 68.4)
- added D31: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (229.1, 68.4)
- added D32: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (232.8, 68.4)
- added D33: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (236.5, 68.4)
- added D34: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (240.2, 68.4)
- added D35: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (244.0, 68.4)
- added D36: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (247.7, 68.4)
- added D37: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (217.9, 75.2)
- added D38: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (221.7, 75.2)
- added D39: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (225.4, 75.2)
- added D4: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (228.0, 27.6)
- added D40: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (229.1, 75.2)
- added D41: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (232.8, 75.2)
- added D42: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (236.5, 75.2)
- added D5: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (231.7, 27.6)
- added D6: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (235.4, 27.6)
- added D7: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (239.1, 27.6)
- added D8: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (242.8, 27.6)
- added D9: LED_Dual_AAKK, XZM2CRKM2DG55W_8:LED_XZM2CRKM2DG55W-8, F.Cu at (246.6, 27.6)
- added J1: Conn_01x04_Pin, Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical, F.Cu at (135.1, 82.5)
- added J3: Conn_01x04_Pin, Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical, F.Cu at (143.5, 82.5)
- added J7: Conn_01x02_Pin, Connector_Molex:Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical, F.Cu at (111.4, 102.3)
- added J8: Conn_01x02_Pin, Connector_Molex:Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical, F.Cu at (111.4, 110.2)
- added LS1: Speaker, Buzzer_Beeper:Buzzer_15x7.5RM7.6, F.Cu at (126.9, 26.5)
- added R1: 100, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (32.5, 80.1)
- added R2: 100, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (32.5, 83.0)
- added R4: 1k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (32.5, 86.0)
- added R5: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (32.5, 89.0)
- added R6: 100, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (32.5, 91.9)
- added U1: SN74AHC1G02MDCKREP, SN74AHC1G02MDCKREP:SOT65P210X110-5N, F.Cu at (37.7, 86.4)
- added U2: M74VHC1GT32DFT1G, KiCad:SOT65P210X110-5N, F.Cu at (37.1, 90.2)
- added U6: LED Driver, Package_TO_SOT_SMD:SC-74-6_1.55x2.9mm_P0.95mm, F.Cu at (146.8, 60.0)
- moved C3 141.5 mm to (146.5, 53.1)
- moved C4 141.5 mm to (146.5, 56.1)
- moved U3 119.6 mm to (116.2, 40.2)
- moved U5 33.7 mm to (29.5, 23.9)

Commit message: update PCB and sketch
added footprints and wire routes
Parts:
- removed J7, J8: Conn_01x02_Pin, Connector_Molex:Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical
- added CR4: BSS806NEH6327XTSA1, footprints:PG-SOT23-3-5_INF, F.Cu at (45.1, 53.1)
- added G***: LOGO, FS_3_Global_Footprint_Library:FORMULA SLUG, F.Cu at (35.6, 90.9)
- added J2: Conn_01x04_Pin, Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical, F.Cu at (76.8, 40.9)
- CR1: value STS6NF20V -> BSS806NEH6327XTSA1
- D1, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D3, D4, D5, D6, D7, D8, D9: moved to B.Cu
- moved D7 199.6 mm to (44.2, 70.5), turned to -90 degrees
- moved D15 196.1 mm to (44.2, 78.0), turned to -90 degrees
- moved D27 195.9 mm to (53.2, 85.4), turned to -90 degrees
- moved D24 193.8 mm to (44.2, 85.4), turned to -90 degrees
- moved D26 191.4 mm to (53.2, 77.9), turned to -90 degrees
- moved D23 189.3 mm to (44.2, 77.9), turned to -90 degrees
- moved D22 189.1 mm to (44.2, 85.5), turned to -90 degrees
- moved D25 187.2 mm to (53.2, 70.4), turned to -90 degrees
- moved D6 187.2 mm to (53.2, 70.5), turned to -90 degrees
- moved D14 183.7 mm to (53.2, 78.0), turned to -90 degrees
- moved D21 176.7 mm to (53.2, 85.5), turned to -90 degrees
- moved D10 176.4 mm to (44.2, 70.4), turned to -90 degrees
- moved D5 174.8 mm to (62.2, 70.5), turned to -90 degrees
- moved D18 174.2 mm to (80.0, 85.5), turned to -90 degrees
- moved D13 171.6 mm to (62.0, 78.0), turned to -90 degrees
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Connections:
- CR1 pad 3: /RED_LIGHT_ARRAY -> /RED_LIGHTS
- CR3 pad 3: /FLASH_LED -> /FLASH_ACTIVE
- J1 pad 3: /IMD_STATUS -> /BMS_STATUS
- J1 pad 4: /BMS_STATUS -> /IMD_STATUS
- J3 pad 4: /RTDS_BUZZER -> /RTDS_SIGNAL
- U1 pad 4: /GREEN_LIGHT_ARRAY -> /GREEN_LIGHT_LOGIC
Routing:
- net /TO_DRIVER: track 0.00 -> 303.7 mm, vias 0 -> 1
- net /GREEN_LIGHTS: track 0.00 -> 175.4 mm, vias 0 -> 1
- net /RED_LIGHTS: track 0.00 -> 153.7 mm, vias 0 -> 1
- net GND: track 0.00 -> 142.8 mm, vias 0 -> 7
- net +12V: track 0.00 -> 74.2 mm, vias 0 -> 2
- net +5V: track 0.00 -> 49.9 mm, vias 0 -> 2
- net /FLASH_ACTIVE: track 0.00 -> 47.8 mm
- net /RTDS_BUZZER: track 0.00 -> 39.1 mm
- net /BMS_STATUS: track 0.00 -> 37.7 mm, vias 0 -> 2
- net /IMD_STATUS: track 0.00 -> 36.0 mm, vias 0 -> 2
- net /FLASH_LEDS: track 0.00 -> 33.3 mm
- net /RTML1_12V: track 0.00 -> 28.4 mm
- net /RTDS_SIGNAL: track 0.00 -> 24.0 mm
- net /RTML2_12V: track 0.00 -> 23.2 mm
- net Net-(U3-THR): track 0.00 -> 19.1 mm
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Other:
- board outline added: 86.5 x 62 mm
- board text added: "By Ethan James - Formula Slug"
- board text added: "Tractive System Status Indicator v1.0"

Commit message: Update Board
new footprints, rearranged board for compactness, adjusted connectors to be horizontal for better enclosure clearance.
Parts:
- removed LS1: Speaker, Buzzer_Beeper:Buzzer_15x7.5RM7.6
- added CR5: BSS806NEH6327XTSA1, BSS806NEH6327XTSA1:PG-SOT23-3-5_INF, F.Cu at (59.5, 71.5)
- added J4: Conn_01x02_Pin, Connector_Molex:Molex_Nano-Fit_105313-xx02_1x02_P2.50mm_Horizontal, F.Cu at (65.5, 71.2)
- added L1: PK-21N30PQ, PK-21N20PQ:PK21N30PQ, F.Cu at (187.5, 74.5)
- CR1, CR2, CR3, CR4: footprint footprints:PG-SOT23-3-5_INF -> BSS806NEH6327XTSA1:PG-SOT23-3-5_INF
- D1: renamed from D10; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D10: renamed from D31; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D11: renamed from D32; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D12: renamed from D33; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D13: renamed from D34; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D14: renamed from D35; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D15: renamed from D36; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D16: renamed from D37; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D17: renamed from D38; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D18: renamed from D39; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D19: renamed from D40; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D2: renamed from D23; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D20: renamed from D41; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D21: renamed from D42; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D22: renamed from D1; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D23: renamed from D8; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D24: renamed from D16; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D25: renamed from D2; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D26: renamed from D9; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D27: renamed from D17; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D28: renamed from D3; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D29: renamed from D11; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D3: renamed from D24; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D30: renamed from D18; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D31: renamed from D4; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D32: renamed from D12; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D33: renamed from D19; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D34: renamed from D5; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D35: renamed from D13; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D36: renamed from D20; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D37: renamed from D6; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D38: renamed from D14; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D39: renamed from D21; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D4: renamed from D25; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D40: renamed from D7; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D41: renamed from D15; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D42: renamed from D22; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D5: renamed from D26; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D6: renamed from D27; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D7: renamed from D28; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D8: renamed from D29; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- D9: renamed from D30; value LED_Dual_AAKK -> XZM2CRKM2DG55W
- J1: footprint Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical -> Connector_Molex:Molex_Nano-Fit_105313-xx04_1x04_P2.50mm_Horizontal
- J2: value Conn_01x04_Pin -> Conn_01x02_Pin; footprint Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical -> Connector_Molex:Molex_Nano-Fit_105313-xx02_1x02_P2.50mm_Horizontal
- J3: footprint Connector_Molex:Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical -> Connector_Molex:Molex_Nano-Fit_105313-xx03_1x03_P2.50mm_Horizontal
- U2: footprint KiCad:SOT65P210X110-5N -> M74VHC1GT32DFT1G:SOT65P210X110-5N
- U5: value LM7805_TO220 -> LD1086DT50TR; footprint Package_TO_SOT_THT:TO-220-3_Vertical -> LD1086DT50TR:LD1086DT33TR
- moved G*** 89.7 mm to (120.5, 62.0)
- moved J3 66.0 mm to (45.2, 86.5), turned to 180 degrees
- moved D27 63.7 mm to (152.7, 84.5)
- moved D29 63.7 mm to (143.7, 77.0)
- moved D30 63.7 mm to (143.7, 84.5)
- moved D32 63.7 mm to (134.7, 77.0)
- moved D33 63.7 mm to (134.7, 84.5)
- moved D1 63.7 mm to (107.9, 69.4)
- moved D10 63.7 mm to (134.9, 69.4)
- moved D11 63.7 mm to (134.9, 76.9)
- moved D12 63.7 mm to (134.9, 84.4)
- moved D13 63.7 mm to (143.9, 69.4)
- moved D14 63.7 mm to (143.9, 76.9)
- moved D15 63.7 mm to (143.9, 84.4)
- moved D16 63.7 mm to (152.9, 69.4)
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- renumbered U1 to U4
Connections:
- J2 pad 2: GND -> /RTML_12V
- J3 pad 2: /RTML1_12V -> /RTML_5V
- J3 pad 3: /RTML2_12V -> /RTDS_SIGNAL
- U5 pad 1: +12V -> GND
- U5 pad 2: GND -> +5V
- U5 pad 3: +5V -> +12V
Routing:
- net /RTDS_BUZZER: track 39.1 -> 137.3 mm
- net GND: track 142.8 -> 226.0 mm, vias 7 -> 9
- net /RED_LIGHTS: track 153.7 -> 217.9 mm
- net +12V: track 74.2 -> 126.1 mm, vias 2 -> 4
- net /GREEN_LIGHTS: track 175.4 -> 210.3 mm
- net /RTML1_12V: track 28.4 -> 0.00 mm
- net /RTML_5V: track 0.00 -> 28.0 mm
- net /RTDS_SIGNAL: track 24.0 -> 51.3 mm, vias 0 -> 2
- net /RTML_12V: track 0.00 -> 26.5 mm
- net /TO_DRIVER: track 303.7 -> 329.6 mm
- net /RTML2_12V: track 23.2 -> 0.00 mm
- net Net-(U3-DIS): track 3.00 -> 22.6 mm, vias 0 -> 2
- net /IMD_STATUS: track 36.0 -> 50.5 mm, vias 2 -> 4
- net +5V: track 49.9 -> 63.9 mm
- net /BMS_STATUS: track 37.7 -> 48.0 mm, vias 2 -> 4
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Other:
- board size 86.5 x 62 mm -> 167.5 x 31.5 mm
- board text added: "ACC Connector"
- board text added: "ETC Connector"
- board text added: "RTML"
