# Repository formulaslug/fs-3-schematics (continued)

## KiCad design Power Distrobution Board/Power DIstrobution Board.kicad_pcb (continued)

Parts:
C4, C6, C9, C10: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
CN2: NUCLEO-L432KC; PARTREV N/A
R1: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U13: CD74HC4067M; SOIC-24W_7.5x15.4mm_P1.27mm
U18: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm

Connections:
+3.3V: C6.1, C9.1, U13.24 (VCC), U18.1 (VCC1); also elsewhere on the board
+5V: C4.2, CN2.CN4_4 (5V), U18.8 (VCC2)
+9V: C10.2, CN2.CN4_1 (VIN); also elsewhere on the board
CAN H: U18.7 (CANH); also elsewhere on the board
CAN L: U18.6 (CANL); also elsewhere on the board
GND: C4.1, C6.2, C9.2, C10.1, CN2.CN3_4 (GND), CN2.CN4_2 (GND), R1.2, U13.12 (GND), U18.4 (GND1), U18.5 (GND2); also elsewhere on the board
unnamed: CN2.CN3_1 (PA9), U13.13 (S3)
unnamed: CN2.CN3_2 (PA10), U13.14 (S2)
unnamed: CN2.CN3_13 (PA11), U18.2 (RXD)
unnamed: CN2.CN3_5 (PA12), U18.3 (TXD)
unnamed: CN2.CN3_6 (PB0), U13.1 (COM)
unnamed: CN2.CN3_8 (PB6), U13.10 (S0)
unnamed: CN2.CN3_7 (PB7), U13.11 (S1)
unnamed: R1.1, U13.15 (~E)
accumulator_viout: U13.21 (I10); also elsewhere on the board
brake_pressure_sensor_viout: U13.7 (I2); also elsewhere on the board
bspd_viout: U13.6 (I3); also elsewhere on the board
dash_viout: U13.20 (I11); also elsewhere on the board
dcdc_ctrl: CN2.CN3_14 (PB5); also elsewhere on the board
etc_viout: U13.17 (I14); also elsewhere on the board
extra1_viout: U13.18 (I13); also elsewhere on the board
extra2_viout: U13.22 (I9); also elsewhere on the board
lv_sense: CN2.CN4_12 (PA0); also elsewhere on the board
pd_board_viout: U13.5 (I4); also elsewhere on the board
ready_to_move_viout: U13.8 (I1); also elsewhere on the board
reset_ctrl: CN2.CN4_11 (PA1); also elsewhere on the board
shutdown_viout: U13.2 (I7); also elsewhere on the board
telemetry_viout: U13.4 (I5); also elsewhere on the board
tractive_viout: U13.23 (I8); also elsewhere on the board

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
Board: 2 copper layers, 155.0 x 130.0 mm, 79 parts (3 on the bottom side), 75 nets.

## KiCad design Accumulator_Board/Accumulator_Board.kicad_pcb

Parts:
C1, C2, C4, C9, C12: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10: 0.33uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11: .33uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C13, C14: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C18: 100nf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C23: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C24: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
CR1, CR2, CR3, CR4, CR5, CR6: STS6NF20V; SOIC-8_3.9x4.9mm_P1.27mm
D2, D4, D5, D6, D7: D; D_2010_5025Metric_Pad1.52x2.65mm_HandSolder
D8: HPZR-C50X; Nexperia_CFP3_SOD-123W
J1: IMD; Molex_Nano-Fit_105309-xx03_1x03_P2.50mm_Vertical; PARTREV H
J2: Molex Nanofit 12pin; Molex_Nano-Fit_105310-xx12_2x06_P2.50mm_Vertical
J3: Temp Sensor; Molex_Nano-Fit_105309-xx03_1x03_P2.50mm_Vertical
J4: Current Sensor; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical; PARTREV H
J6: Shutdown IL; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical; PARTREV H
J7: AIRs Power; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical; PARTREV H
J8: Precharge Resistor; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical; PARTREV H
J9: TS+/TS-; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical
J10: HVIL; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical
J11: Molex Nanofit 16pin; Molex_Nano-Fit_105310-xx16_2x08_P2.50mm_Vertical
K1, K3: DK1A1B-12V; DK1A1B
K2: G5PZ-1A-X DC12
K4: G6BK-1114P-US; RELAY_G6BK-1114P-US_OMR
Q1, Q2: STS6NF20V; SOIC-8_3.9x4.9mm_P1.27mm
Q3: BSS308PE; SOT-23_Handsoldering
R1: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R26, R29, R33, R34, R38: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 120k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 200k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6: 400k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R8: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17: 22k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18: 6.8K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R19, R22, R25, R28, R30, R31, R32: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R20: 1.6k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21: 560; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R23: 10M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R27, R39: 7.15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R35: 3.9k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R36: 18k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R37: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP3, TP4, TP5: TestPoint; TestPoint_Pad_D1.5mm
U1: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm
U2: NUCLEO-L432KC; PARTREV N/A
U3: SN74LS279ADR; SOIC-16_3.9x9.9mm_P1.27mm
U5: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm
U6: DS18B20U; MSOP-8_3x3mm_P0.65mm
U7: HEF4093B; SOIC-14_3.9x8.7mm_P1.27mm
U9: L7805CV; TO-220-3_Vertical
U10: MC7809CTG; TO-220-3_Vertical
U11: SN74HCS08DR; SOIC-14_3.9x8.7mm_P1.27mm
U12: SN74LVC1G17DBVR; SOT-23-5
U15: ZXTR2005ZQ-13; SOT-89_4P5X2P45_DIO
U16: MC14069UBDR2G; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3.3V: C2.2, R24.1, U1.1 (VCC1), U2.CN4_14 (3V3); also elsewhere on the board
+5V: C1.2, C4.2, C9.2, C12.2, C14.1, C18.2, J3.3, J4.1, Q3.1 (G), R23.1, R29.1, U1.8 (VCC2), U3.16 (VCC), U5.4 (V+), U7.14 (VCC), U9.3 (OUT), U11.14 (VCC), U12.5 (VCC), U16.14 (VDD)
+9V: C13.1, U2.CN4_1 (VIN), U10.3 (VO)
+12V: C10.1, C11.1, D2.1 (K), D4.1 (K), D5.1 (K), J1.2, J11.1, K1.8 (+), K3.8 (+), K4.5, R33.1, R34.1, R36.2, U9.1 (IN), U10.1 (VI)
/ACC_Temp_Sense: J3.2, R24.2, U2.CN3_8 (PB6)
/Amp_Curr_Sensor: R3.1, R4.1, U2.CN4_10 (PA3)
/BMS_CS: U2.CN4_9 (PA4); also elsewhere on the board
/BMS_Dash_LED_Control: CR6.5 (D), CR6.6 (D), CR6.7 (D), CR6.8 (D), J2.1, R34.2
/BMS_FAULT_3.3V: R25.1, R30.2, U2.CN3_7 (PB7)
/BMS_FAULT_5V: CR4.5 (D), CR4.6 (D), CR4.7 (D), CR4.8 (D), J11.10, R29.2, U11.5
/BMS_Fault_Inverted: R22.2, R28.2, U2.CN4_6 (PA7)
/BMS_RL: CR3.5 (D), CR3.6 (D), CR3.7 (D), CR3.8 (D), D2.2 (A), K1.1 (-)
/BSPD_FAULT_5V: J2.4, U7.5
/CAN1_RD: U1.2 (RXD), U2.CN3_13 (PA11)
/CAN1_TD: U1.3 (TXD), U2.CN3_5 (PA12)
/CAN_H1: J11.3, J11.5, U1.7 (CANH)
/CAN_L1: J11.4, R1.2, U1.6 (CANL)
/CAN_L_RES1: J11.6, R1.1
/CLK: U2.CN4_15 (PB3); also elsewhere on the board
/Charge_State: J11.9, R2.2, U2.CN3_2 (PA10)
/Current_Vout: J2.9, R7.2, U5.8, U5.9 (-)
/Current_Vref: J2.8, R8.2, U5.6 (-), U5.7
/Fan_PWM: J11.7, U2.CN3_12 (PA8)
/GLV Voltage: R35.2, R36.1, U2.CN4_12 (PA0)
/HVIL: C24.1, J10.1, U15.3 (Vout)
/IMD_DELAY: R19.1, R31.2, U3.6 (~S), U7.10, U7.12, U11.4
/IMD_Dash_LED_Control: CR5.5 (D), CR5.6 (D), CR5.7 (D), CR5.8 (D), J2.3, R33.2
/IMD_Delay_Latch: R32.2, U3.7 (Q), U16.9
/IMD_FAULT_12V: J1.1, R20.2, R26.1
/IMD_RL: CR1.5 (D), CR1.6 (D), CR1.7 (D), CR1.8 (D), D4.2 (A), K3.1 (-)
/IMD_Status: R20.1, R21.2, U2.CN3_6 (PB0)
/IMD_TSSI_Control: J11.11, U16.8
/IR+_12V: D7.1 (K), J2.7, J7.2, J7.4, K2.1, R17.1
/IR+_GND: J7.1, J11.8, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D)
/LATCH_RL: CR2.5 (D), CR2.6 (D), CR2.7 (D), CR2.8 (D), D5.2 (A), K4.2
/Latch_Gate_TP: CR2.4 (G), U7.4
/MISO: U2.CN3_15 (PB4); also elsewhere on the board
/MOSI: U2.CN3_14 (PB5); also elsewhere on the board
/Precharge_Control: Q1.4 (G), U2.CN3_9 (PB1), U16.5
/Raw_Curr_Out: J4.3, R9.1, U5.10 (+)
/Raw_Curr_VRef: J4.4, U5.5 (+)
/SH_RESET: D6.1 (K), J2.10, K4.6, R38.1
/Schmitt Output: U7.8, U11.1, U12.4
/Shutdown_ACC_BMS_TP: K1.4, K3.3, TP3.1
/Shutdown_ACC_IMD_TP: J6.1, K3.4, TP4.1
/Shutdown_ACC_In: J2.5, K1.3
/Shutdown_ACC_Out: J2.6, K4.3, TP5.1
/Shutdown_Measure: R17.2, R18.1, U2.CN4_5 (PA2)
/TS+: D8.1 (K), J9.1
/TS-: C23.2, C24.2, J9.2, J10.2, U15.1 (GND)
/TSSI_TP: U7.6, U11.6
/Temp_Sense_GND: J2.11, U6.4 (GND), U6.8 (V_{DD})
/Temp_Sense_One_Wire: J2.12, U6.1 (DQ)
GND: C1.1, C2.1, C3.1, C4.1, C9.1, C10.2, C11.2, C12.1, C13.2, C14.2, C18.1, CR1.1 (S), CR1.2 (S), CR1.3 (S), CR2.1 (S), CR2.2 (S), CR2.3 (S), CR3.1 (S), CR3.2 (S), CR3.3 (S), CR4.1 (S), CR4.2 (S), CR4.3 (S), CR5.1 (S), CR5.2 (S), CR5.3 (S), CR6.1 (S), CR6.2 (S), CR6.3 (S), D6.2 (A), J1.3, J3.1, J4.2, J7.3, J11.2, K4.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.1 (S), Q2.2 (S), Q2.3 (S), R2.1, R3.2, R6.1, R9.2, R18.2, R19.2, R21.1, R25.2, R27.2, R35.1, R37.2, R39.2, U1.4 (GND1), U1.5 (GND2), U2.CN3_4 (GND), U2.CN4_2 (GND), U3.8 (GND), U5.11 (V-), U7.7 (GND), U9.2 (GND), U10.2 (GND), U11.7 (GND), U12.3 (GND), U16.7 (VSS); also elsewhere on the board
unnamed: CR1.4 (G), R31.1
unnamed: CR3.4 (G), R30.1
unnamed: CR4.4 (G), R28.1
unnamed: CR5.4 (G), R32.1
unnamed: CR6.4 (G), R22.1
unnamed: D7.2 (A), K2.4, Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D)
unnamed: C23.1, D8.2 (A), U15.2 (Vin)
unnamed: J6.2, K4.4
unnamed: J8.1, K2.2
unnamed: J8.2, K2.3
unnamed: Q2.4 (G), U16.6
unnamed: Q3.3 (D), R37.1
unnamed: C3.2, Q3.2 (S), R23.2, U12.2
unnamed: R4.2, R5.1, U5.1
unnamed: R26.2, R27.1, U16.3
unnamed: R38.2, R39.1, U7.13
unnamed: U3.5 (~R), U11.3
unnamed: R6.2, R7.1, U5.3 (+)
unnamed: R5.2, R8.1, U5.2 (-)
unnamed: U7.11, U11.2
unnamed: U7.9, U16.4

Notes on the sheet:
Energy Meter Temp Sense
SR Latch
Check polarity and annotate
--> BMS Relay
12V --> ~5V Input to LV Logic at 5V
Latch Trigger MOSFET
NAND GATE
GLV
Voltage Indicator
Double check where the Voltage Indicator will go out to
IsoSPI
ACC Onboard Shutdown
Hex Invertor
1 Turns on Light 0 Turns off Light when SH_Reset is hit
3.3V
--> IMD Relay
Power Block
AIR power from shutdown circuit; inside acc
When BMS Fault 3.3V is low BMS_Fault_5V is low
Upstream delay of ~11sec durring power on
BMS Fault Low --> 5V Relay
CAN Transciever
LEDS
On fault condition triggers TSSI light
IMD Fault Low 3.3V --> 5V Relay
IMD Relay
Auxillary Connector
Schmitt Trigger, Delay before turn on ~4secs worst case
IMD_Delay and BMS Fault_5V to be used to drive TSSI logic
Precharge Circuit
Shutdown interlock (BFC), inside ACC
SPST Latching Relay
BMS Relay
Microcontroller
For DS18B20 one wire temp sensors For acc air temperature sensing
0V or 8-12V
Goes to IMD; inside ACC
0V or 2-3.3V
AND GATE
HPZR-C50-QX

Parts:
C5, C6: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7: 15pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J5: IsoSPI; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical; PARTREV H
L1: HM2113ZNL; HM2113ZNLT
R10: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 1.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 680; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 402; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14: 200; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R16: 22; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1: IsoSPI_P; TestPoint_Loop_D2.50mm_Drill1.0mm
TP2: IsoSPI_N; TestPoint_Loop_D2.50mm_Drill1.0mm
U8: LTC6820; MSOP-16_3x4.039mm_P0.5mm

Connections:
+3.3V: C5.1, C6.1, R10.2, U8.1 (EN), U8.6 (V_DDS), U8.9 (V_DD), U8.12 (MSTR); also elsewhere on the board
/BMS_CS: U8.5 (CS); also elsewhere on the board
/CLK: U8.4 (SCK); also elsewhere on the board
/Iso SPI/IBIAS: R11.2, U8.16 (IBIAS)
/Iso SPI/ICMP: R11.1, R12.2, U8.15 (ICMP)
/Iso SPI/extIsoSPI_N: J5.1, R16.1, TP2.1
/Iso SPI/extIsoSPI_P: J5.2, R15.1, TP1.1
/Iso SPI/isoSPI_+: L1.4, R13.1, U8.11 (IP)
/Iso SPI/isoSPI_-: C7.1, L1.6, U8.10 (IM)
/MISO: R10.1, U8.3 (MISO); also elsewhere on the board
/MOSI: U8.2 (MOSI); also elsewhere on the board
GND: C5.2, C6.2, C8.2, R12.1, U8.7 (POL), U8.8 (PHA), U8.13 (SLOW), U8.14 (GND); also elsewhere on the board
unnamed: C7.2, R13.2
unnamed: C8.1, L1.5
unnamed: L1.1, R14.2, R16.2
unnamed: L1.3, R14.1, R15.2

Notes on the sheet:
This module was designed as specified in the LTC6811 datasheet.
ISOSpi Bias setting
SPI - isoSPI conversion
ISOSpi isolation and filtering

Board: 2 copper layers, 127.0 x 91.5 mm, 105 parts (0 on the bottom side), 85 nets.

## KiCad design Live_Telemetry_Receiver_Board_V2/Live_Telemetry_Receiver_Board_V2.kicad_pcb

Parts:
C3: 1.0 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 47 pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
CN1: NUCLEO-L432KC; PARTREV N/A
U2: XBP9B-DPST-001

Connections:
+3V3: C3.1, C4.1, CN1.CN4_14 (3V3), U2.1 (VCC)
/IMU_SCL: CN1.CN4_11 (PA1)
/Radio_ATTN: CN1.CN3_8 (PB6), U2.19 (AD1/DIO1/SPI_NATTN)
/Radio_MISO: CN1.CN4_7 (PA6), U2.4 (DIO12/SPI_MISO)
/Radio_MOSI: CN1.CN4_6 (PA7), U2.11 (DIO4/SPI_MOSI)
/Radio_Reset: U2.5 (~RESET)
/Radio_SCK: CN1.CN4_8 (PA5), U2.18 (AD2/DIO2/SPI_CLK)
/Radio_SS: CN1.CN3_6 (PB0), U2.17 (AD3/DIO3/SPI_NSSEL)
GND: C3.2, C4.2, CN1.CN4_2 (GND), U2.10 (GND)

Board: 2 copper layers, 53.5 x 68.0 mm, 4 parts (0 on the bottom side), 7 nets.
