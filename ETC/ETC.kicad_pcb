# Repository formulaslug/fs-3-schematics

File README.md:

# Notes

This Branch Contains the Tractive System Status Indicator (TSSI) board Schematic and PCB

Description:

The TSSI indicates via an array of Red/Green Light the status of the Tractive System (ETC).
In the event that there is a falure In either the BMS or IMD as signaled by the ETC
board the indicator will flash Red at ~2Hz signaling the driver and crew that the vehicle
is fault. The function of the board is also to hold the Ready-To-Drive-Sound (RTDS) Piezo and 
Ready-To-Move-Light(s) RTML where logic and power for both indicators is off of the ETC board.

Direct Questions to : Ethan James - Shutdown Subteam

## KiCad design ETC/ETC.kicad_pcb

Parts:
BSE1: TestPoint; PinHeader_1x01_P2.54mm_Vertical
C1, C3: .33 µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C4: .1 µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6, C7: 40 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C9, C14, C15, C16: 100 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C13: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
CN1: NUCLEO-L432KC; PARTREV N/A
CR1: STS6NF20V; PowerIntegrations_SO-8
Cockpit1: TestPoint; PinHeader_1x01_P2.54mm_Vertical
HE1, HE2: TestPoint; PinHeader_1x01_P2.54mm_Vertical
J1: 1053101212; Molex_Nano-Fit_105310-xx12_2x06_P2.50mm_Vertical
J2: 1053101206; Molex_Nano-Fit_105310-xx06_2x03_P2.50mm_Vertical
R1, R5, R6, R8: 180kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R9: 330kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4, R7: 100kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10, R11: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: 120Ω; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R18: 1kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17, R19: 200kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
Reverse1: TestPoint; PinHeader_1x01_P2.54mm_Vertical
U2: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm
U3: LM7805_TO220; TO-220-3_Horizontal_TabUp
U4: LM7809_TO220; TO-220-3_Horizontal_TabUp
U6: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm

Connections:
+3V3: C9.1, C12.1, CN1.CN4_14 (3V3), J1.9, R16.1, R18.1, U6.1
+5V: C2.1, C8.1, C13.1, J2.3, J2.4, U2.4 (V+), U3.3 (VO), U6.8
+9V: C4.1, C16.1, CN1.CN4_1 (VIN), U4.3 (VO)
+12V: C1.1, C3.1, J1.5, U3.1 (VI), U4.1 (VI)
/BSE: BSE1.1, C7.1, CN1.CN4_12 (PA0), R8.2, R9.1
/BSE_RAW: J1.11, R7.1, U2.10 (+)
/Brake_Light: CR1.5 (D), CR1.6 (D), CR1.7 (D), CR1.8 (D), J1.7
/Brake_Switch: CN1.CN3_15 (PB4), R10.1, R11.2
/CAN_RD: CN1.CN3_13 (PA11), U6.2 (RXD)
/CAN_TD: CN1.CN3_5 (PA12), U6.3 (TXD)
/Cockpit_Raw: J1.10, R16.2, R17.2
/Cockpit_Signal: C14.1, CN1.CN3_6 (PB0), Cockpit1.1, R17.1
/HE1: C5.1, CN1.CN4_6 (PA7), HE1.1, R1.2, R2.1
/HE1_RAW: J2.2, R3.1, U2.3 (+)
/HE2: C6.1, CN1.CN4_11 (PA1), HE2.1, R5.2, R6.1
/HE2_RAW: J2.1, R4.1, U2.5 (+)
/H_CAN: J1.3, R15.1, U6.7 (CANH)
/L_CAN: J1.4, R15.2, U6.6 (CANL)
/RTDS_Switch: CN1.CN3_14 (PB5), J1.8
/Reverse_Raw: J1.1, R18.2, R19.2
/Reverse_Signal: C15.1, CN1.CN3_9 (PB1), R19.1, Reverse1.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C12.2, C13.2, C14.2, C15.2, C16.2, CN1.CN4_2 (GND), CR1.1 (S), CR1.2 (S), CR1.3 (S), J1.2, J1.6, J2.5, J2.6, R2.2, R3.2, R4.2, R6.2, R7.2, R9.2, R11.1, U2.11 (V-), U2.12 (+), U3.2 (GND), U4.2 (GND), U6.4 (GND1), U6.5 (GND2)
unnamed: CR1.4 (G), R10.2
unnamed: R1.1, U2.1, U2.2 (-)
unnamed: R5.1, U2.6 (-), U2.7
unnamed: R8.1, U2.8, U2.9 (-)
unnamed: U2.13 (-), U2.14

Notes on the sheet:
Hall Effect 1
Brake System Encoder
+3.3V
RTDS_Switch
Hall Effect 2
GND
Brake_Light
Brake Light MOSFET
CAN Tranciever
Cockpit
Digital Input Debouncing
Reverse
H_CAN
9V and 5V Linear Regulators
+12V
Analog Input Scaling
+5V
Nanofit header
L_CAN
MCU Connections

Board: 2 copper layers, 74.5 x 70.0 mm, 43 parts (0 on the bottom side), 27 nets.

## KiCad design TSSI_Revision/TSSI.kicad_pcb

Board: 2 copper layers, 154.2 x 32.8 mm, 112 parts (40 on the bottom side), 81 nets.

Parts:
C1: 22nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 330nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5, C6, C7: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
CR1, CR2, CR3, CR4: BSS806NEH6327XTSA1; PG-SOT23-3-5_INF
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: T1681NG--20C000112U1930
D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60: T1681USD-20C000312U1930; T1681NG--20C000112U1930
J1: 1053131103; Molex_Nano-Fit_105313-xx03_1x03_P2.50mm_Horizontal
J2: 1053131104; Molex_Nano-Fit_105313-xx04_1x04_P2.50mm_Horizontal
J3, J4: 1053131102; Molex_Nano-Fit_105313-xx02_1x02_P2.50mm_Horizontal
L1: AI-3035-TT-12V-R
R1, R3, R4, R5, R6, R27, R28, R29, R30, R31: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 10M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17, R18, R19, R20, R21, R22, R23, R24, R25, R26: 470; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R32: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: LM555xN; M08A
U2: LD1086DT50TR; LD1086DT33TR
U3: SN74AHC1G00DCKR; SOT65P210X110-5N
U4: SN74AHC1G08DCKR; SOT65P210X110-5N

Connections:
+5V: C4.1, C5.1, C6.1, C7.1, R1.2, U1.8 (VCC), U2.2 (OUT), U3.5 (VCC), U4.5 (VCC)
+12V: C2.1, J2.2, J3.2, J4.2, L1.P, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, U2.3 (IN)
/BMS_STATUS: J2.3, R32.1, U3.1, U4.1
/FLASH_LEDS: R30.1, U1.3 (Q)
/GREEN_LIGHTS: CR4.3, D3.1 (K), D3.2 (K), D3.3 (K), D6.1 (K), D6.2 (K), D6.3 (K), D9.1 (K), D9.2 (K), D9.3 (K), D12.1 (K), D12.2 (K), D12.3 (K), D15.1 (K), D15.2 (K), D15.3 (K), D18.1 (K), D18.2 (K), D18.3 (K), D21.1 (K), D21.2 (K), D21.3 (K), D24.1 (K), D24.2 (K), D24.3 (K), D27.1 (K), D27.2 (K), D27.3 (K), D30.1 (K), D30.2 (K), D30.3 (K)
/GREEN_LIGHT_LOGIC: R29.1, U4.4
/IMD_STATUS: J2.4, R31.1, U3.2, U4.2
/RED_LIGHTS: CR2.3, D33.1 (K), D33.2 (K), D33.3 (K), D36.1 (K), D36.2 (K), D36.3 (K), D39.1 (K), D39.2 (K), D39.3 (K), D42.1 (K), D42.2 (K), D42.3 (K), D45.1 (K), D45.2 (K), D45.3 (K), D48.1 (K), D48.2 (K), D48.3 (K), D51.1 (K), D51.2 (K), D51.3 (K), D54.1 (K), D54.2 (K), D54.3 (K), D57.1 (K), D57.2 (K), D57.3 (K), D60.1 (K), D60.2 (K), D60.3 (K)
/RED_LIGHT_LOGIC: U1.4 (R), U3.4
/RTDS_BUZZER: CR1.3, L1.N
/RTDS_SIGNAL: J1.3, R27.1
/RTML_5V: J1.2, R28.1
/RTML_12V: CR3.3, J3.1, J4.1
GND: C1.1, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, CR1.2, CR2.2, CR3.2, CR4.2, J1.1, J2.1, R3.1, R4.1, R5.1, R6.1, R31.2, R32.2, U1.1 (GND), U2.1 (GND/ADJ), U3.3 (GND), U4.3 (GND)
unnamed: CR1.1, R3.2, R27.2
unnamed: CR2.1, R4.2, R30.2
unnamed: CR3.1, R5.2, R28.2
unnamed: CR4.1, R6.2, R29.2
unnamed: D1.4 (A), R7.2
unnamed: D1.1 (K), D1.2 (K), D1.3 (K), D2.4 (A)
unnamed: D2.1 (K), D2.2 (K), D2.3 (K), D3.4 (A)
unnamed: D4.4 (A), R8.2
unnamed: D4.1 (K), D4.2 (K), D4.3 (K), D5.4 (A)
unnamed: D5.1 (K), D5.2 (K), D5.3 (K), D6.4 (A)
unnamed: D7.4 (A), R9.2
unnamed: D7.1 (K), D7.2 (K), D7.3 (K), D8.4 (A)
unnamed: D8.1 (K), D8.2 (K), D8.3 (K), D9.4 (A)
unnamed: D10.4 (A), R10.2
unnamed: D10.1 (K), D10.2 (K), D10.3 (K), D11.4 (A)
unnamed: D11.1 (K), D11.2 (K), D11.3 (K), D12.4 (A)
unnamed: D13.4 (A), R11.2
unnamed: D13.1 (K), D13.2 (K), D13.3 (K), D14.4 (A)
unnamed: D14.1 (K), D14.2 (K), D14.3 (K), D15.4 (A)
unnamed: D16.4 (A), R12.2
unnamed: D16.1 (K), D16.2 (K), D16.3 (K), D17.4 (A)
unnamed: D17.1 (K), D17.2 (K), D17.3 (K), D18.4 (A)
unnamed: D19.4 (A), R13.2
unnamed: D19.1 (K), D19.2 (K), D19.3 (K), D20.4 (A)
unnamed: D20.1 (K), D20.2 (K), D20.3 (K), D21.4 (A)
unnamed: D22.4 (A), R14.2
unnamed: D22.1 (K), D22.2 (K), D22.3 (K), D23.4 (A)
unnamed: D23.1 (K), D23.2 (K), D23.3 (K), D24.4 (A)
unnamed: D25.4 (A), R15.2
unnamed: D25.1 (K), D25.2 (K), D25.3 (K), D26.4 (A)
unnamed: D26.1 (K), D26.2 (K), D26.3 (K), D27.4 (A)
unnamed: D28.4 (A), R16.2
unnamed: D28.1 (K), D28.2 (K), D28.3 (K), D29.4 (A)
unnamed: D29.1 (K), D29.2 (K), D29.3 (K), D30.4 (A)
unnamed: D31.4 (A), R17.2
unnamed: D31.1 (K), D31.2 (K), D31.3 (K), D32.4 (A)
unnamed: D32.1 (K), D32.2 (K), D32.3 (K), D33.4 (A)
unnamed: D34.4 (A), R18.2
unnamed: D34.1 (K), D34.2 (K), D34.3 (K), D35.4 (A)
unnamed: D35.1 (K), D35.2 (K), D35.3 (K), D36.4 (A)
unnamed: D37.4 (A), R19.2
unnamed: D37.1 (K), D37.2 (K), D37.3 (K), D38.4 (A)
unnamed: D38.1 (K), D38.2 (K), D38.3 (K), D39.4 (A)
unnamed: D40.4 (A), R20.2
unnamed: D40.1 (K), D40.2 (K), D40.3 (K), D41.4 (A)
unnamed: D41.1 (K), D41.2 (K), D41.3 (K), D42.4 (A)
unnamed: D43.4 (A), R21.2
unnamed: D43.1 (K), D43.2 (K), D43.3 (K), D44.4 (A)
unnamed: D44.1 (K), D44.2 (K), D44.3 (K), D45.4 (A)
unnamed: D46.4 (A), R22.2
unnamed: D46.1 (K), D46.2 (K), D46.3 (K), D47.4 (A)
unnamed: D47.1 (K), D47.2 (K), D47.3 (K), D48.4 (A)
unnamed: D49.4 (A), R23.2
unnamed: D49.1 (K), D49.2 (K), D49.3 (K), D50.4 (A)
unnamed: D50.1 (K), D50.2 (K), D50.3 (K), D51.4 (A)
unnamed: D52.4 (A), R24.2
unnamed: D52.1 (K), D52.2 (K), D52.3 (K), D53.4 (A)
unnamed: D53.1 (K), D53.2 (K), D53.3 (K), D54.4 (A)
unnamed: D55.4 (A), R25.2
unnamed: D55.1 (K), D55.2 (K), D55.3 (K), D56.4 (A)
unnamed: D56.1 (K), D56.2 (K), D56.3 (K), D57.4 (A)
unnamed: D58.4 (A), R26.2
unnamed: D58.1 (K), D58.2 (K), D58.3 (K), D59.4 (A)
unnamed: D59.1 (K), D59.2 (K), D59.3 (K), D60.4 (A)
unnamed: C3.2, U1.5 (CV)
unnamed: R1.1, R2.2, U1.7 (DIS)
unnamed: C1.2, R2.1, U1.2 (TR), U1.6 (THR)

## KiCad design Telemetry peripheral boards/FS3 Peripheral V4 ATTINY/F3 peripheral boards.kicad_pcb

Parts:
C1: 10pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C5, C6, C7, C8, C9, C10, C14: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 22nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12: 330nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15: 100 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C16, C17: 22 pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: TS4148 RBG; D_0805_2012Metric
J1: ATS668LSM; Molex_Nano-Fit_105309-xx03_1x03_P2.50mm_Vertical
J2: Main Connector; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical
J3: Potentiometer; Molex_Nano-Fit_105309-xx03_1x03_P2.50mm_Vertical
J4: Strain Gauge; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical
J5: Tire temp Sensor; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical
J6: 1x1 Tire Air Temp Sensor; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical
J7: 1x8 Tire Surface Temp Sensor; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical
J9, J10: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
R1, R6: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R5, R13: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R9: 120R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8, R15: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: Extra; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 60.4R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 430; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV1: 200R; Potentiometer_Bourns_3296W_Vertical
U1: LM2907M/NOPB; SOIC-14_3.9x8.7mm_P1.27mm
U2: INA125U; SOIC-16_3.9x9.9mm_P1.27mm
U3: MCP2515-I/SO; SOIC-18W_7.5x11.6mm_P1.27mm
U4: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm
U5: ATtiny1616-S; SOIC-20W_7.5x12.8mm_P1.27mm
U7: LM7805CV; TO-220-3_Vertical
Y1: STDCSU1-8M; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
+5V: C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C14.1, D1.1 (K), J1.1, J3.1, J4.1, J5.1, J6.2, J7.2, J9.8, R1.2, R3.1, R7.1, R8.1, R14.1, R15.1, U1.8 (COL), U1.9 (V+), U2.1 (V+), U2.2 (*SLEEP), U3.18 (VDD), U4.1 (VCC1), U4.8 (VCC2), U5.1 (VCC), U7.3 (VO)
+12V: C12.1, J2.1, U7.1 (VI)
/Vin+: J4.2, R9.1, U2.6 (VIN+)
/Vin-: R7.2, RV1.1, RV1.2, U2.7 (VIN-)
/VrefBG: U2.4 (VREFOUT), U2.5 (IAREF), U2.13 (VREFBG)
CAN1_RX: U3.2 (RXCAN), U4.2 (RXD)
CAN1_TX: U3.1 (TXCAN), U4.3 (TXD)
CAN MOSI: J9.6, U3.14 (SI), U5.17 (PA1)
CANH: J2.3, J5.3, U4.7 (CANH)
CANL: J2.2, J5.2, U4.6 (CANL)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.1, C10.1, C12.2, C14.2, C15.2, C16.1, C17.2, J1.3, J2.4, J3.3, J5.4, J6.1, J7.1, J9.9, R2.2, R5.2, R6.2, R9.2, RV1.3, U1.12 (GND), U2.3 (V-), U2.12 (VREFCOM), U3.9 (VSS), U4.4 (GND1), U4.5 (GND2), U5.20 (GND), U7.2 (GND)
unnamed: C4.1, U1.2 (CP)
unnamed: C15.1, D1.2 (A), R13.2, R14.2
unnamed: C1.1, J1.2, R3.2, U1.1 (TACH+)
unnamed: R10.1, R11.1, U2.8 (RG)
unnamed: R10.2, R11.2, U2.9 (RG)
unnamed: R4.1, R5.1, U1.5 (EMIT), U1.10 (IN-)
unnamed: C3.1, R6.1, U1.3 (CP), U1.4 (IN+)
unnamed: R1.1, R2.1, U1.11 (TACH-)
unnamed: R13.1, U3.17 (*RESET)
unnamed: C17.1, U3.8 (OSC1), Y1.1
unnamed: C16.2, U3.7 (OSC2), Y1.2
unnamed: R12.1, U5.16 (~RESET/PA0)
PA3/SCK: J10.10, U3.13 (SCK), U5.19 (PA3)
PA5: J10.8, U5.3 (PA5)
PA6: J3.2, J10.7, U5.4 (PA6)
PB0: J6.4, J7.4, J9.1, R15.2, U5.11 (PB0)
PB1: J6.3, J7.3, J10.1, R8.2, U5.10 (PB1)
PB2: J10.2, U5.9 (PB2)
PB3: J10.3, U5.8 (PB3)
PB4: J10.4, U5.7 (PB4)
PB5: J10.5, U5.6 (PB5)
PC0: J9.2, U5.12 (PC0)
PC1: J9.3, U5.13 (PC1)
PC2: J9.4, U5.14 (PC2)
Strain: J10.6, U2.10 (VO), U2.11 (SENSE), U5.5 (PA7)
UPDI: J9.10, R12.2
Wheel Speed: C2.1, J9.5, R4.2, U5.15 (PC3)

Notes on the sheet:
Cap to ground for filtering
Wheel Speed Sensor Connector
Changed to Pot was previously resistor and arrow
Changed from ground to 5V Pull down -> pull up
10 goes to 5 not ground
Changed Crystal to 8 MHz to fit mcp2515
R is traditionally used for ones place number (120)
CAN Controller
ATtiny1616 SOIC 20-Pin Microcontroller
Instrumentation Amplifier
Wheatstone Bridge
3.43V

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
Board: 2 copper layers, 70.7 x 40.3 mm, 48 parts (0 on the bottom side), 40 nets.

## KiCad design Discharge/Discharge.kicad_pcb

Board: 2 copper layers, 90.4 x 51.7 mm, 29 parts (0 on the bottom side), 17 nets.

Parts:
C1, C3: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 0.01uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C6: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: HPZR-C50-QX; Nexperia_CFP3_SOD-123W
D2: 20v; D_2010_5025Metric
J1: TS; Molex_Nano-Fit_105309-xx03_1x03_P2.50mm_Vertical
J2: TSMP; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical
J3: Conn_01x06; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical
J4: Conn_01x02; Molex_Nano-Fit_105309-xx02_1x02_P2.50mm_Vertical
K1: 1109537; Relay_DPDT_Omron_G5V-2
R1: 200k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R4: 5k; R_Axial_Power_L20.0mm_W6.4mm_P22.40mm
R3: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 1k; R_0805_2012Metric
TP1: IRF; TestPoint_Loop_D2.50mm_Drill1.0mm
TP2: 5V; TestPoint_Loop_D2.50mm_Drill1.0mm
TP3: RTM; TestPoint_Loop_D2.50mm_Drill1.0mm
TP4: 12V; TestPoint_Loop_D2.50mm_Drill1.0mm
TP5: GND; TestPoint_Loop_D2.50mm_Drill1.0mm
TP6: U3Vin; TestPoint_Loop_D2.50mm_Drill1.0mm
TP7: U3Vout; TestPoint_Loop_D2.50mm_Drill1.0mm
U1: NE555DR; D8
U2, U3: ZXTR2005ZQ-13; SOT-89-3_Handsoldering
U4: TLP3122AE; SO-5-6_4.55x3.7mm_P1.27mm

Connections:
5V: C2.1, C6.1, R5.2, TP2.1, U1.4 (R), U1.8 (VCC), U2.3 (VO)
12V_out: C5.1, TP4.1, U2.2 (VI), U4.4
12v: J3.1, U4.6
GND: C1.2, C2.2, C5.2, C6.2, D2.2 (A), J3.2, K1.16, TP5.1, U1.1 (GND), U2.1 (GND)
IR_FINAL: D2.1 (K), J3.4, K1.1, TP1.1
unnamed: C3.1, D1.2 (A), TP6.1, U3.2 (VI)
unnamed: D1.1 (K), J1.3, R2.2
unnamed: C3.2, C4.2, J1.1, R4.1, U3.1 (GND), U4.3
unnamed: J2.1, R4.2
unnamed: J2.2, R2.1
unnamed: J4.1, K1.11
unnamed: J4.2, K1.13
unnamed: R3.2, U4.1
unnamed: R1.2, R5.1, U1.7 (DIS)
unnamed: C1.1, R1.1, U1.2 (TR), U1.6 (THR)
unnamed: C4.1, R3.1, TP7.1, U3.3 (VO)
RTM: J3.3, TP3.1, U1.3 (Q)

## KiCad design TelemetryMainFinal/TelemMainFinal/TelemMainFinal.kicad_pcb

Parts:
J1: 8 pin ATM connector; ATM13-8PA-BM03
J3: 12 pin ATM connector; ATM13-12PA-BM03

Connections:
+3V3: J3.3; also elsewhere on the board
+12VIN: J3.2; also elsewhere on the board
Acc Exhaust Temp: J3.8; also elsewhere on the board
Acc Intake Flow Rate: J3.10; also elsewhere on the board
Acc Intake Pressure: J3.9; also elsewhere on the board
Acc Intake Temp: J3.7; also elsewhere on the board
Brake Sensor B: J3.6; also elsewhere on the board
Brake Sensor F: J3.5; also elsewhere on the board
CAN1_H: J1.3, J1.4; also elsewhere on the board
CAN1_L: J1.1, J1.2; also elsewhere on the board
GND: J3.1, J3.11; also elsewhere on the board
Steering Sensor: J3.4; also elsewhere on the board

Notes on the sheet:
1 CAN bus -> 2 CAN Busses SPI Connected to 2 can controllers https://ww1.microchip.com/downloads/en/DeviceDoc/MCP2515-Stand-Alone-CAN-Controller-with-SPI-20001801J.pdf peripheral boards being replaced with CAN (Except power and ground) Make a list of sensors that need to be powered by PDB Reach out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
out to steering sensor

Parts:
C13: 100nf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J4: SD to SPI (Molex nanofit); Molex_Nano-Fit_105310-xx10_2x05_P2.50mm_Vertical

Connections:
+3V3: C13.1, J4.1; also elsewhere on the board
GND: C13.2, J4.2; also elsewhere on the board
SD CS2: J4.6; also elsewhere on the board
SD Card Detect T/F: J4.9; also elsewhere on the board
SD MISO2: J4.4; also elsewhere on the board
SD MOSI2: J4.5; also elsewhere on the board
SD SCK2: J4.3; also elsewhere on the board
