# Repository formulaslug/fs-3-schematics (continued)

## KiCad design TelemetryMainFinal/TelemMainFinal/TelemMainFinal.kicad_pcb (continued)

Parts:
U8: Adafruit_E336755_10DoF_IMU

Connections:
+5V: U8.1 (VIN); also elsewhere on the board
GND: U8.3 (GND), U8.GND (GND2); also elsewhere on the board
IMU GINT: U8.6 (GINT); also elsewhere on the board
IMU GRDY: U8.7 (GRDY); also elsewhere on the board
IMU LINT1: U8.8 (LINT1); also elsewhere on the board
IMU LINT2: U8.9 (LINT2); also elsewhere on the board
IMU LRDY: U8.10 (LRDY); also elsewhere on the board
IMU SCL: U8.4 (SCL); also elsewhere on the board
IMU SDA: U8.5 (SDA); also elsewhere on the board

Notes on the sheet:
<- optional output interrupt/ready pins for the IMU's gyroscope (G) and accelerometer/magnotomer (L1/L2)

Parts:
C7, C8: 100nf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U4: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm

Connections:
+3V3: C8.2, U4.1 (VCC1); also elsewhere on the board
+5V: C7.2, U4.8 (VCC2); also elsewhere on the board
CAN1_H: U4.7 (CANH); also elsewhere on the board
CAN1_L: U4.6 (CANL); also elsewhere on the board
CAN1_RX: U4.2 (RXD); also elsewhere on the board
CAN1_TX: U4.3 (TXD); also elsewhere on the board
GND: C7.1, C8.1, U4.4 (GND1), U4.5 (GND2); also elsewhere on the board

Notes on the sheet:
CAN1 transceiver

Parts:
C14: 100nf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R5, R7, R12: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R8, R13: 20k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U6: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: C14.1, U6.4 (V+); also elsewhere on the board
Brake Sensor B: U6.5 (+); also elsewhere on the board
Brake Sensor F: U6.3 (+); also elsewhere on the board
Brake Sensor F 3V3: R7.2, R8.2; also elsewhere on the board
Brake Sensor R 3V3: R5.2, R6.2; also elsewhere on the board
GND: C14.2, R6.1, R8.1, R13.1, U6.11 (V-); also elsewhere on the board
unnamed: R7.1, U6.1, U6.2 (-)
unnamed: R5.1, U6.6 (-), U6.7
unnamed: R12.1, U6.8, U6.9 (-)
Steering Sensor: U6.10 (+); also elsewhere on the board
Steering Sensor 3V3: R12.2, R13.2; also elsewhere on the board

Notes on the sheet:
Unused Opamp Channel
Opamp Voltage Supply

Parts:
C11: 1.0 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12: 47 pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U5: XBP9B-DPST-001

Connections:
+3V3: C11.1, C12.1, U5.1 (VCC); also elsewhere on the board
GND: C11.2, C12.2, U5.10 (GND); also elsewhere on the board
Radio ATTN: U5.19 (AD1/DIO1/SPI_NATTN); also elsewhere on the board
Radio CS1: U5.17 (AD3/DIO3/SPI_NSSEL); also elsewhere on the board
Radio MISO1: U5.4 (DIO12/SPI_MISO); also elsewhere on the board
Radio MOSI1: U5.11 (DIO4/SPI_MOSI); also elsewhere on the board
Radio Reset: U5.5 (~RESET); also elsewhere on the board
Radio SCK1: U5.18 (AD2/DIO2/SPI_CLK); also elsewhere on the board

Parts:
J5: F3311A7H121030E200; AMPHENOL_F3311A7H121030E200; PARTREV A

Connections:
+3V3: J5.2, J5.3, J5.5, J5.6; also elsewhere on the board
+5V: J5.25, J5.26, J5.28, J5.29; also elsewhere on the board
Dash CS3: J5.18; also elsewhere on the board
Dash MISO3: J5.12; also elsewhere on the board
Dash MOSI3: J5.10; also elsewhere on the board
Dash SCK3: J5.8; also elsewhere on the board
GND: J5.1, J5.4, J5.7, J5.9, J5.11, J5.13, J5.15, J5.17, J5.19, J5.24, J5.27, J5.30; also elsewhere on the board
INT: J5.20; also elsewhere on the board
PD: J5.22; also elsewhere on the board

Parts:
C5: 100nf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R1: 1 kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 3 kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 4.7k; R_0805_2012Metric
U3: NUCLEO-F446RE; PARTREV 13

Connections:
+3V3: R11.1, U3.CN7_5 (VDD), U3.CN7_16 (CN7_+3V3); also elsewhere on the board
+9V: C5.1, U3.CN7_24 (CN7_VIN); also elsewhere on the board
+12VIN: R2.2; also elsewhere on the board
Acc Exhaust Temp: U3.CN7_32 (PA4); also elsewhere on the board
Acc Intake Flow Rate: U3.CN7_28 (PA0); also elsewhere on the board
Acc Intake Pressure: U3.CN7_30 (PA1); also elsewhere on the board
Acc Intake Temp: U3.CN7_34 (PB0); also elsewhere on the board
Brake Sensor F 3V3: U3.CN7_36 (PC1/PB9); also elsewhere on the board
Brake Sensor R 3V3: U3.CN7_38 (PC0/PB8); also elsewhere on the board
CAN1_RX: U3.CN10_3 (PB8); also elsewhere on the board
CAN1_TX: U3.CN10_5 (PB9); also elsewhere on the board
Dash CS3: U3.CN7_4 (PD2); also elsewhere on the board
Dash MISO3: U3.CN7_2 (PC11); also elsewhere on the board
Dash MOSI3: U3.CN7_3 (PC12); also elsewhere on the board
Dash SCK3: U3.CN7_1 (PC10); also elsewhere on the board
GND: C5.2, R1.1, U3.CN7_8 (CN7_GND), U3.CN7_19 (CN7_GND__1), U3.CN7_20 (CN7_GND__2), U3.CN7_22 (CN7_GND__3), U3.CN10_9 (CN10_GND), U3.CN10_20 (CN10_GND__1), U3.CN10_32 (AGND); also elsewhere on the board
IMU GINT: U3.CN7_31 (PH1); also elsewhere on the board
IMU GRDY: U3.CN7_29 (PH0); also elsewhere on the board
IMU LINT1: U3.CN7_17 (PA15); also elsewhere on the board
IMU LINT2: U3.CN7_15 (PA14); also elsewhere on the board
IMU LRDY: U3.CN7_13 (PA13); also elsewhere on the board
IMU SCL: U3.CN10_25 (PB10); also elsewhere on the board
IMU SDA: U3.CN10_31 (PB3); also elsewhere on the board
INT: R11.2, U3.CN7_23 (PC13); also elsewhere on the board
unnamed: R1.2, R2.1, U3.CN7_35 (PC2)
PD: U3.CN7_21 (PB7); also elsewhere on the board
Radio ATTN: U3.CN10_21 (PA9); also elsewhere on the board
Radio CS1: U3.CN10_2 (PC8); also elsewhere on the board
Radio MISO1: U3.CN10_13 (PA6); also elsewhere on the board
Radio MOSI1: U3.CN10_15 (PA7); also elsewhere on the board
Radio Reset: U3.CN10_19 (PC7); also elsewhere on the board
Radio SCK1: U3.CN10_11 (PA5); also elsewhere on the board
SD CS2: U3.CN10_16 (PB12); also elsewhere on the board
SD Card Detect T/F: U3.CN10_24 (PB1); also elsewhere on the board
SD MISO2: U3.CN10_28 (PB14); also elsewhere on the board
SD MOSI2: U3.CN10_26 (PB15); also elsewhere on the board
SD SCK2: U3.CN10_30 (PB13); also elsewhere on the board
Steering Sensor 3V3: U3.CN10_6 (PC5); also elsewhere on the board

Notes on the sheet:
Voltage check

Schematic: power_distribution.kicad_sch

Parts:
C1, C2: 330nf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4: 100nf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: EEE-FK1C562SM; CP_Elec_18x17.5
D1: ACGRAT105L-HF; D_2010_5025Metric_Pad1.52x2.65mm_HandSolder
D3, D4: QBLP631-R3A; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14, R15: 470R 1/4W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: LM7805_TO220; TO-220-3_Vertical
U2: LM7809_TO220; TO-220-3_Vertical

Connections:
+5V: C3.1, U1.3 (VO); also elsewhere on the board
+9V: C4.1, U2.3 (VO); also elsewhere on the board
+12V: C1.1, C2.1, C9.1, D1.1 (K), R15.1, U1.1 (VI), U2.1 (VI)
+12VIN: D1.2 (A), R14.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C9.2, D3.1 (K), D4.1 (K), U1.2 (GND), U2.2 (GND); also elsewhere on the board
unnamed: D3.2 (A), R14.2
unnamed: D4.2 (A), R15.2

Notes on the sheet:
Linear Regulators
Status LEDs

Board: 2 copper layers, 173.4 x 88.1 mm, 38 parts (0 on the bottom side), 50 nets.

Other parts of the board:
G1: FS Logo; FS Logo Big

## KiCad design Power Distrobution Board/Power DIstrobution Board.kicad_pcb

Parts:
J2: AT15-6P-BM01GRY; CONN6_DT15-6P_TEC
J5: ATM15-12PA-BM03; TE_DTM15-12PA

Connections:
CAN H: J5.9; also elsewhere on the board
CAN L: J5.10; also elsewhere on the board
GND: J5.11; also elsewhere on the board
accumulator_out: J2.3; also elsewhere on the board
brake_pressure_sensor_9v: J5.4, J5.8; also elsewhere on the board
bspd_out: J5.3; also elsewhere on the board
dash_out: J2.4; also elsewhere on the board
etc_out: J5.2; also elsewhere on the board
extra1_out: J5.1; also elsewhere on the board
extra2_out: J2.2; also elsewhere on the board
glvms1: J2.5; also elsewhere on the board
ready_to_move_out: J5.7; also elsewhere on the board
set+_out: J5.12; also elsewhere on the board
shutdown_out: J5.5; also elsewhere on the board
telemetry_out: J5.6; also elsewhere on the board
tractive_out: J2.1; also elsewhere on the board

Parts:
CR1, CR2: STS6NF20V; SOIC-8_3.9x4.9mm_P1.27mm
D1, D2, D3: ACGRAT105L-HF; D_2010_5025Metric_Pad1.52x2.65mm_HandSolder
F1: 01530008LXN
J3: AT15-4P-BM01; CONN4_DT15-4P-G003
K2: EW60-1A3-CL12D04,00000; EW601A3CL12D0400000; Manufacturer_Part_Number EW60-1A3-CL12D04,00000
K3: AZ2150-1A-12DEF; AZ2150_AMZ
Q1: BSS308PE; SOT-23_Handsoldering
R14: 4k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
GND: CR1.1 (S), CR1.2 (S), CR1.3 (S), CR2.1 (S), CR2.2 (S), CR2.3 (S), D2.2 (A), D3.2 (A), J3.1, J3.4, K2.A1 (S-/R-), R15.2; also elsewhere on the board
unnamed: CR1.5 (D), CR1.6 (D), CR1.7 (D), CR1.8 (D), D1.2 (A), K3.5
unnamed: D1.1 (K), F1.2, K2.4 (COM_1), K3.1, K3.4, Q1.2 (S), R16.1
unnamed: D2.1 (K), K2.A3 (R+), Q1.3 (D)
unnamed: J3.2, K3.2
unnamed: CR2.5 (D), CR2.6 (D), CR2.7 (D), CR2.8 (D), Q1.1 (G), R16.2
dcdc_ctrl: CR1.4 (G); also elsewhere on the board
glvms1: F1.1; also elsewhere on the board
lv_batt_voltage: J3.3, K2.1 (NO_1), R14.1
lv_sense: R14.2, R15.1; also elsewhere on the board
reset_ctrl: CR2.4 (G); also elsewhere on the board
set+_out: D3.1 (K), K2.A2 (S+); also elsewhere on the board

Notes on the sheet:
DC/DC
LV BATT

Parts:
C1: 0.33uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C5: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U1: LF33CV 3.3v linear reg; TO-220-3_Horizontal_TabDown
U14: MC7809CTG 9v linear reg; TO-220-3_Horizontal_TabDown

Connections:
+3.3V: C3.2, U1.3 (OUT); also elsewhere on the board
+9V: C2.2, U14.3 (OUT); also elsewhere on the board
GND: C1.1, C2.1, C3.1, C5.1, U1.2 (GND), U14.2 (GND); also elsewhere on the board
pd_board_out: C1.2, C5.2, U1.1 (IN), U14.1 (IN); also elsewhere on the board

Parts:
C7: 0.33uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U15: MC7809CTG 9v linear reg; TO-220-3_Horizontal_TabDown

Connections:
GND: C7.1, C8.1, U15.2 (GND); also elsewhere on the board
brake_pressure_sensor_9v: C8.2, U15.3 (OUT); also elsewhere on the board
brake_pressure_sensor_out: C7.2, U15.1 (IN); also elsewhere on the board

Notes on the sheet:
backwards 1 in 2 gnd 3 out

Parts:
C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
F2, F3, F4, F5, F6, F7, F8, F9, F10, F11, F12, F13: 01530008LXN
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U2, U3, U4, U5, U7, U8, U9, U10, U11, U12, U16, U17: ACS71240LLCBTR-025B3; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, U2.8 (VCC), U3.8 (VCC), U4.8 (VCC), U5.8 (VCC), U7.8 (VCC), U8.8 (VCC), U9.8 (VCC), U10.8 (VCC), U11.8 (VCC), U12.8 (VCC), U16.8 (VCC), U17.8 (VCC); also elsewhere on the board
GND: C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, U2.5 (GND), U3.5 (GND), U4.5 (GND), U5.5 (GND), U7.5 (GND), U8.5 (GND), U9.5 (GND), U10.5 (GND), U11.5 (GND), U12.5 (GND), U16.5 (GND), U17.5 (GND); also elsewhere on the board
unnamed: F2.2, U2.1 (IP+), U2.2 (IP+)
unnamed: F3.2, U3.1 (IP+), U3.2 (IP+)
unnamed: F4.2, U4.1 (IP+), U4.2 (IP+)
unnamed: F5.2, U5.1 (IP+), U5.2 (IP+)
unnamed: F6.2, U7.1 (IP+), U7.2 (IP+)
unnamed: F7.2, U8.1 (IP+), U8.2 (IP+)
unnamed: F8.2, U9.1 (IP+), U9.2 (IP+)
unnamed: F9.2, U10.1 (IP+), U10.2 (IP+)
unnamed: F10.2, U11.1 (IP+), U11.2 (IP+)
unnamed: F11.2, U12.1 (IP+), U12.2 (IP+)
unnamed: F12.2, U16.1 (IP+), U16.2 (IP+)
unnamed: F13.2, U17.1 (IP+), U17.2 (IP+)
unnamed: R2.2, U2.6 (FAULT)
unnamed: R8.2, U3.6 (FAULT)
unnamed: R7.2, U4.6 (FAULT)
unnamed: R6.2, U5.6 (FAULT)
unnamed: R3.2, U7.6 (FAULT)
unnamed: R9.2, U8.6 (FAULT)
unnamed: R10.2, U9.6 (FAULT)
unnamed: R11.2, U10.6 (FAULT)
unnamed: R4.2, U11.6 (FAULT)
unnamed: R5.2, U12.6 (FAULT)
unnamed: R12.2, U16.6 (FAULT)
unnamed: R13.2, U17.6 (FAULT)
accumulator_out: U5.3 (IP-), U5.4 (IP-); also elsewhere on the board
accumulator_viout: U5.7 (VIOUT); also elsewhere on the board
brake_pressure_sensor_out: U10.3 (IP-), U10.4 (IP-); also elsewhere on the board
brake_pressure_sensor_viout: U10.7 (VIOUT); also elsewhere on the board
bspd_out: U9.3 (IP-), U9.4 (IP-); also elsewhere on the board
bspd_viout: U9.7 (VIOUT); also elsewhere on the board
dash_out: U8.3 (IP-), U8.4 (IP-); also elsewhere on the board
dash_viout: U8.7 (VIOUT); also elsewhere on the board
etc_out: U7.3 (IP-), U7.4 (IP-); also elsewhere on the board
etc_viout: U7.7 (VIOUT); also elsewhere on the board
extra1_out: U11.3 (IP-), U11.4 (IP-); also elsewhere on the board
extra1_viout: U11.7 (VIOUT); also elsewhere on the board
extra2_out: U12.3 (IP-), U12.4 (IP-); also elsewhere on the board
extra2_viout: U12.7 (VIOUT); also elsewhere on the board
pd_board_out: U17.3 (IP-), U17.4 (IP-); also elsewhere on the board
pd_board_viout: U17.7 (VIOUT); also elsewhere on the board
ready_to_move_out: U4.3 (IP-), U4.4 (IP-); also elsewhere on the board
ready_to_move_viout: U4.7 (VIOUT); also elsewhere on the board
shutdown_out: U2.3 (IP-), U2.4 (IP-); also elsewhere on the board
shutdown_viout: U2.7 (VIOUT); also elsewhere on the board
telemetry_out: U3.3 (IP-), U3.4 (IP-); also elsewhere on the board
telemetry_viout: U3.7 (VIOUT); also elsewhere on the board
tractive_out: U16.3 (IP-), U16.4 (IP-); also elsewhere on the board
tractive_viout: U16.7 (VIOUT); also elsewhere on the board
